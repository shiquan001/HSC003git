# Keil uVision project zhihuiwenshiV3.0.uvprojx, settings and files
target zhihuiwenshiV3.0 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L476RETx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: zhihuiwenshiV3.0 +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L476xx
  c include: ..\bsp;                                                                                                    ../Inc;                                                                                                    ../Drivers/STM32L4xx_HAL_Driver/Inc;                                                                                                    ../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy;                                                                                                    ../Drivers/CMSIS/Device/ST/STM32L4xx/Include;                                                                                                    ../Drivers/CMSIS/Include;                                                                                                    ..\app;                                                                                                    ..\NBxxModule;                                                                                                    ..\bsp\UART_DMA_CFG;                                                                                                    ..\GPS_Parse;                                                                                                    ..\GY_JSON
  library: MicroLIB
  memory RVCT4: ROM 0x8020000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32l476xx.s
  group bsp
    ../bsp/: bsp.c bsp_camera.c bsp_timer.c bsp_i2c_gpio.c bsp_uart_fifo.c timer_user_poll.c bsp_gps_l70_r.c bsp_LUX_V20.c bsp_SHT10.c bsp_HT1621.c bsp_key_set.c bsp_cpu_flash.c stmflash.c bsp_spi_flash.c bsp_spi_bus.c bsp_SHT30A.c flash_if.c bsp_modbus.c bsp_user_lib.c bsp_msg.c bsp_SHT20A.c bsp_fifo_cmd.c
  group app
    ../app/: app_picture.c debug.c delay.c app_zigbee.c app_zigbee_HA.c app_wenshi.c app_gps.c app_nb.c app_display.c app_battery.c app_caiji.c app_config.c app_update.c GMT_time.c app_camera.c heart_led.c app_caiji_PLC.c app_fault_analysis.c app_fifo_NB_CoapST.c app_sheshisuo_PLC.c app_4g.c app_update_4g.c
  group Application/User
    ../Src/: main.c gpio.c adc.c dma.c iwdg.c usart.c rtc.c spi.c stm32l4xx_it.c stm32l4xx_hal_msp.c app_main.c
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_iwdg.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_exti.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group app/NBxxModule
    ../NBxxModule/: NB_BC95.c NB_Board.c NB_Board_Cfg.c
  group app/UartDma
    ../bsp/UART_DMA_CFG/: _dma_cfg.c
  group app/GY_JSON
    ../GY_JSON/: json_format.c
software components: CMSIS:CORE 5.0.0
